<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NFC_L432KC.ewp</path>
  </project>
  <batchBuild />
</workspace>
